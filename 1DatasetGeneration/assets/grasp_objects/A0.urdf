Commit message: Update A0.urdf

File: 1DatasetGeneration/assets/grasp_objects/A0.urdf (robot description, URDF)
Before this commit: robot A0, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=A0_collision.obj; visual mesh filename=A0_visual.obj
