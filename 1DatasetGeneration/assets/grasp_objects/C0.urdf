Commit message: Update C0.urdf

File: 1DatasetGeneration/assets/grasp_objects/C0.urdf (robot description, URDF)
Before this commit: robot C0, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=C0_collision.obj; visual mesh filename=C0_visual.obj
