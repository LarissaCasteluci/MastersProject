Commit message: Update teapot.urdf

File: 1DatasetGeneration/assets/grasp_objects/teapot.urdf (robot description, URDF)
Before this commit: robot teapot, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=teapot_collision.obj; visual mesh filename=teapot_visual.obj
